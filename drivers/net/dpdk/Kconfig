## drivers/net/dpdk/Kconfig
```kconfig
config NET_DPDK
	tristate "DPDK ethernet driver"
	default y
	help
	  DPDK ethernet driver.
```
